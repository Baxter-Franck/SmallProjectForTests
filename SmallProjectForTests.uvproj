# Keil uVision project SmallProjectForTests.uvproj, settings and files
target TM4C1294KCPDT (ARM-ADS)
  device: TM4C1294KCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x00000000-0x0007FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Sortie +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: PART_TM4C1294KCPDT UART_PRINTF_ENABLED
  c include: .\lib\driverlib;.\lib\inc;.\lib;.\sources;.\sources\fonctions
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Sources
    ./sources/: main.c startup_TM4C129.s
  group Fonctions
    ./sources/fonctions/: ddi_I2C.c ioExp.c ioExp2.c myFunctions.c watchdog_ext.c
    ./sources/Fonctions/: myEeprom.c ddi_I2C_franck.c ddi_scale_eeprom_i2c.c
  group Librairies
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/: sysctl.c cpu.c interrupt.c gpio.c i2c.c
    ./lib/driverlib/: uart.c uartstdio.c
  group out
    ./out/: App_Flash.ini
